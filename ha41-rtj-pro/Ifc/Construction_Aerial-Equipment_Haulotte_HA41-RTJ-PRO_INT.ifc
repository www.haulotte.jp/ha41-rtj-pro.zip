Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Numéro du projet
Time: 2020-09-16T13:29:03
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.6.0.0 - Interface alternative d'export 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 16 13:29:03 2020 * Host: N08 * Database: C:\Users\N~1\AppData\Local\Temp\{17F55D53-C17A-4518-9EB6-C941C3F383DE}\ifc * Database version: 5507 * Database creation date: Wed Sep 16 13:28:53 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 16 13:28:53 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 16 13:28:53 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Numéro du projet
LongName: Nom du projet; Phase: Etat du projet

# IfcSite, Default
RefLatitude: 48, 51, 23, 999633; RefLongitude: 2, 21, 3, 553905; RefElevation: 0 m
Autre - Adresse du projet: Entrer l'adresse ici; Catégorie: Informations sur le projet; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Autre - Catégorie: Informations sur le projet; Adresse du projet: Entrer l'adresse ici; Date de fin du projet: Date de fin; Etat du projet: Etat du projet; Nom du client: Propriétaire; Nom du projet: Nom du projet; Numéro de projet: Numéro du projet

# IfcBuildingStorey, Niveau 0
LongName: Niveau 0; Elevation: -1.94916e-14 m
Graphismes(Type) - Couleur: 12632256; Epaisseur des lignes: 1; Motif des lignes: Tiret point; Symbole: Marqueur de niveau - Point triangulaire: Marqueur de niveau - Point triangulaire; Valeur par défaut du symbole à l'extrémité 1: no; Valeur par défaut du symbole à l'extrémité 2: yes
Données d'identification(Type) - Nom du type: Ligne du Niveau
Contraintes(Type) - Base de l'élévation: Point de base du projet
Autre - Catégorie: Niveaux; Famille: Niveau: Ligne du Niveau; Famille et type: Niveau: Ligne du Niveau; ID du type: Niveau: Ligne du Niveau; Type: Niveau: Ligne du Niveau
Contraintes - Elévation: 0 m
Cotes - Hauteur de calcul: 0 m
Données d'identification - Etage de bâtiment: yes; Nom: Niveau 0; Structure: no
Autre(Type) - Catégorie: Niveaux; Nom de la famille: Niveau

# IfcBuildingElementProxy: HA 41 RTJ PRO, Construction_Aerial-Equipment_Haulotte_HA41-RTJ-PRO_INT:HA 41 RTJ PRO:4036188
In: Niveau 0
Type - Classification: E10 Equipement (Uniformat); Material: Metal - Haulotte - Red, Metal - Haulotte - Black, Metal - Haulotte - Grey, Metal - Haulotte - White, Metal - Haulotte - Yellow, Haulotte, Working_Area, Metal - Haulotte - Grey Dark
Type - Autre(Type) - Catégorie: Equipement spécialisé; Machine Weight: 23 900 kg / 52690.48 lb; Nom de la famille: Construction_Aerial-Equipment_Haulotte_HA41-RTJ-PRO_INT
Type - Données d'identification(Type) - Code d'assemblage: E10; Description: Diesel Articulating Boom; Description de l'assemblage: Equipement; Fabricant: Haulotte; Modèle: HA 41 RTJ PRO; Nom du type: HA 41 RTJ PRO; Note d'identification: 11000; Numéro OmniClass: 23.15.99.00; Product data url: https://www.bimobject.com/haulotte/product/ha41-rtj-pro; Titre OmniClass: Other Utility and Transportation Construction Products; URL: http://www.haulotte.co.uk
Type - Données(Type) - Batteries: 12 V - 155 Ah; Drive Speed: 5-0.5 km/h / 3.11-0.31 mph; Gradeability: 40%; Ground Clearance: 0.294 m / 11,57 in; Height - Storage / Transport: 3.95 m / 155.51 in; Height - Stowed: 2.99 m / 117.72 in; Horizontal Outreach: 20.1 m / 791.34 in; Jib Length: 2.55 m / 100.39 in; Lenght - Storage/Transport: 11m / 43.31 in; Length - Stowed: 13.1 m / 515.75 in; Lift Capacity: 230 kg / 507.06 lb; Max Ground Pressure of Wheel on Paved Ground: 13.2 daN/cm² / 27036 lbf/cm²; Oscillating Angle: 2°/-2°; Platform Height: 39.5m / 1555.12 in; Platform Rotation: +90°/-90°; Platform Size: 2.44x0.915 m/96.06x36.02 in; Tailswing: 2.26 m / 88,98 in; Tilt: 4°; Tires: 1.1x0.438 m/43.31x17.24 in; Turnable Rotation: 360°; Turning Radius - Inside: 2.615 m / 102.95 in; Turning Radius - Outside: 5.740 m / 225.98 in; Up and Over Clearance: 17.5 m / 688.98 in; Vertical Jib Rotation Angle: +70°/-70 °; Wheelbase: 3.5 m / 137.8 in; Width: 2.53 m / 99.61 in; Working Height: 41.5 m / 1633.86 in
Type - Général(Type) - Edition number: 1
Pset_BuildingElementProxyCommon - Reference: HA 41 RTJ PRO
Pset_ManufacturerTypeInformation - Manufacturer: Haulotte
Autre - A: 70 deg; Catégorie: Equipement spécialisé; Famille: Construction_Aerial-Equipment_Haulotte_HA41-RTJ-PRO_INT: HA 41 RTJ PRO; Famille et type: Construction_Aerial-Equipment_Haulotte_HA41-RTJ-PRO_INT: HA 41 RTJ PRO; H: 17.5 m; ID du type: Construction_Aerial-Equipment_Haulotte_HA41-RTJ-PRO_INT: HA 41 RTJ PRO; Type: Construction_Aerial-Equipment_Haulotte_HA41-RTJ-PRO_INT: HA 41 RTJ PRO
Construction - Axle Extension: yes; Boom Rotation Angle: 70 deg; Maximum Boom Articulation Point Height: 17.5 m; Platform Rotation Angle: 0 deg; Reach Diagram: yes; Telescopic Extend: 21.42 m; Turnable Rotation: 0 deg; Turning Radius: yes; Vertical Jib Rotation Angle: 60 deg; Working Area: yes
Contraintes - Décalage: 0 m; Hôte: Niveau : Niveau 0; Niveau: Niveau: Niveau 0; Se déplace avec les éléments voisins: no
Cotes - Surface: 309.552 m2; Volume: 81.5114 m3
Graphismes - Branding: yes
Phase de construction - Phase de création: Nouvelle construction
